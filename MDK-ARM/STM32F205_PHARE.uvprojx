# Keil uVision project STM32F205_PHARE.uvprojx, settings and files
target STM32F205_PHARE (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F205RE STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F205_PHARE
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F2xx_HAL_Driver/Inc;  ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F2xx/Include;  ../Drivers/CMSIS/Include;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ..\Inc\bsp
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_ll_usb.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_spi.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pwr.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_i2c.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_uart.c stm32f2xx_hal_flash.c stm32f2xx_hal_sd.c stm32f2xx_ll_sdmmc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Application/User
    ../Src/: stm32f2xx_hal_msp.c main.c stm32f2xx_it.c freertos.c stm32f2xx_hal_timebase_TIM.c
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
    ../Src/: app_led.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c croutine.c queue.c event_groups.c list.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group bsp
    ../Src/bsp/led/: bsp_led.c
software components: CMSIS:CORE 4.1.0
